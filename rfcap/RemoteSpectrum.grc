options:
  parameters:
    author: David L Norris <dave@webaugur.com>
    copyright: 2021 David L Norris
    description: Spectrum Analyzer with OOK decoder
    generate_options: qt_gui
    id: RemoteSpectrum
    output_language: python
    title: Spectrum
  states: {}

blocks:
- name: prefix
  id: variable
  parameters:
    value: os.path.join(os.path.dirname(os.path.dirname(os.path.abspath(__file__))), "rfcap", "captures") + os.sep
  states: {}
- name: recfile
  id: variable
  parameters:
    value: prefix + datetime.now().strftime("%Y.%m.%d.%H.%M.%S") + ".dat"
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '18'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    orient: Qt.Horizontal
    start: '192000'
    step: '1000'
    stop: '20000000'
    value: '200000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: Squelch
    orient: Qt.Horizontal
    start: '-70'
    step: '1'
    stop: '70'
    value: '0'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '26500000'
    step: '5000'
    stop: '27500000'
    value: '27095000'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '0'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '1'
    type: complex
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '.015'
    init: '0'
    low: '.015'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: recfile
    samp_rate: samp_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '1000'
    decim: '50'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: import_1
  id: import
  parameters:
    imports: |-
      from datetime import datetime
      import os
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: rf_gain + 10
    freq0: tuning
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: rf_gain + 10
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RF Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"RMS"'
    size: '10000'
    srate: samp_rate
    type: float
    ymax: '.15'
    ymin: '-.15'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Threshold"'
    size: '1000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_rms_xx_0, '0', blocks_threshold_ff_1, '0']
- [blocks_rms_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_1, '0', blocks_wavfile_sink_0, '0']
- [blocks_threshold_ff_1, '0', qtgui_time_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0, '0', blocks_rms_xx_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
