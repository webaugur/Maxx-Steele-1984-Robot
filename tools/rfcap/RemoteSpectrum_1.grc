options:
  parameters:
    author: David L Norris <dave@webaugur.com>
    copyright: 2021 David L Norris
    description: Spectrum Analyzer with OOK decoder
    generate_options: qt_gui
    id: RemoteSpectrum
    output_language: python
    title: Spectrum
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '35'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    orient: Qt.Horizontal
    start: '192000'
    step: '1000'
    stop: '20000000'
    value: '1000000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '26500000'
    step: '5000'
    stop: '27500000'
    value: '27095000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '.75'
    init: '0'
    low: '.5'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: rf_gain + 10
    freq0: tuning
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: rf_gain + 10
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RF Signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: '1613'
    fc: '0'
    fftsize: '1024'
    name: '"OOK Data"'
    plotconst: 'False'
    plotfreq: 'False'
    plotwaterfall: 'False'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_sink_x_1, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
